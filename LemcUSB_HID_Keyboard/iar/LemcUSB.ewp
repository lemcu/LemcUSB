# IAR project LemcUSB.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32ZG110F32 EnergyMicro EFM32ZG110F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32ZG110F32
  ICCARM.CCIncludePath2: ../src; ../CMSIS/Include; ../emlib/inc; ../Device/EnergyMicro/EFM32ZG/Include; ../LemcUSB
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../src; ../CMSIS/Include; ../emlib/inc; ../Device/EnergyMicro/EFM32ZG/Include
  OBJCOPY.OOCOutputFile: LemcUSB.bin
  ILINK.IlinkOutputFile: LemcUSB.out
  ILINK.IlinkIcfFile: EFM32ZG110F32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32ZG110F32
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32ZG110F32.icf
  group (top)
    ../: infostorage.txt
  group Application
    ./: EFM32ZG110F32.icf
    ../src/: main.c usb_descriptors.h
  group CMSIS
    ../Device/EnergyMicro/EFM32ZG/Source/IAR/: startup_efm32zg.s
    ../Device/EnergyMicro/EFM32ZG/Source/: system_efm32zg.c
  group emlib
    ../emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_dac.c em_dbg.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_idac.c em_int.c em_lcd.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group LemcUSB
    ../LemcUSB/: usb.c usb_config.h usb_helperfunctions.h usb_hid.c usb_internal_bitbangusb.s usb_internal_ll.c usb_internal_prot_handling.s usb_stack.c
